KBRANCH_genericx86-64-ext = "v5.10/standard/base"
SRCREV_machine_genericx86-64-ext ?= "ab49d2db98bdee2c8c6e17fb59ded9e5292b0f41"
SRCREV_machine_generic-aarch64 ?= "ab49d2db98bdee2c8c6e17fb59ded9e5292b0f41"
KMACHINE_genericx86-64-ext ?= "common-pc-64"
COMPATIBLE_MACHINE = "genericx86-64-ext|generic-aarch64"
LINUX_VERSION = "5.10.43"
