KMACHINE:generic-amd64 ?= "common-pc-64"
COMPATIBLE_MACHINE = "^(generic-amd64|generic-aarch64)$"
