INTERNAL_DEVICE_KERNEL = "md127 nvme0n1 sda sdb mmcblk0 mmcblk1"
INTERNAL_DEVICE_BOOTLOADER_CONFIG = "grub.cfg_internal"
INTERNAL_DEVICE_BOOTLOADER_CONFIG_PATH = "/EFI/BOOT/grub.cfg"
