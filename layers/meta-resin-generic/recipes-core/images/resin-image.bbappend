DEPENDS_remove = "kernel-modules-headers"

IMAGE_FSTYPES_append = " ${RESIN_ROOT_FSTYPE}"
